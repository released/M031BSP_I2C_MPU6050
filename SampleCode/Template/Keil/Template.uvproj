# Keil uVision project Template.uvproj, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc;..\..\Template;..\MPU6050\example;..\MPU6050\interface;..\MPU6050\src;..\MPU6050\test
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c timer.c uart.c i2c.c
  group User
    ../: main.c i2c_driver.c misc_config.c MPU6050.c Adafruit_MPU6050.c
  group MPU6050
    ../MPU6050/example/: driver_mpu6050_basic.c driver_mpu6050_dmp.c driver_mpu6050_fifo.c
    ../MPU6050/interface/: driver_mpu6050_interface.c
    ../MPU6050/src/: driver_mpu6050.c mutex.c
    ../MPU6050/test/: driver_mpu6050_dmp_pedometer_test.c driver_mpu6050_dmp_read_test.c driver_mpu6050_dmp_tap_orient_motion_test.c driver_mpu6050_fifo_test.c driver_mpu6050_read_test.c driver_mpu6050_register_test.c
